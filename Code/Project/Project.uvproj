# Keil uVision project Project.uvproj, settings and files
target Eagle1_8_App (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Eagle1_8_App +hex
  AfterMake: fromelf.exe --bin -o .\obj\Eagle1_8_App.bin .\obj\Eagle1_8_App.axf
  AfterMake: AutoCopy.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,VECT_TAB_FLASH,USE_STDPERIPH_DRIVER
  c misc: --no_multibyte_chars
  c include: ..\Board_Support_Package;..\Config;..\GUI\Core;..\GUI\JPEG;..\GUI\LCDDriver;..\GUI\MultiLayer;..\GUI\Widget;..\GUI\WM;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\CMSIS\Include;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\Res;..\User\UserWindow;..\User;..\USB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Cpu
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Board_Suppot_Package
    ../Board_Support_Package/: adc.c ads8320.c buzzer.c delay.c gps.c i2c.c keypad.c Language.c md5.c public_function.c rtc.c time_calc.c voice.c spi_flash.c spi_hw_driver.c spi_sim_driver.c spi_flash_efficient_rw.c uart.c gpio.c printer.c
  group User
    ../User/: app.c data.c lock.c main.c parameter.c sample.c test.c quick_test.c system_misc.c calibrate.c gprs.c gprs_user.c uart_process.c dfu_config.c
  group User/Res
    ../User/Res/: BATTERY1.c BATTERY2.c BATTERY3.c BATTERY4.c BATTERY5.c BATTERY6.c Cancel_Pressed.c Cancel_Released.c Caption_Bottom.c GPS_Location.c GPS_Search.c KeyBoard_Pressed.c KeyBoard_Released.c Left Button_Pressed_BK.c Left Button_UnPressed_BK.c Left_Arrows_Pressed.c Left_Arrows_Released.c Logo.c Middle Button_Pressed_BK.c Middle Button_UnPressed_BK.c Right_Arrows_Pressed.c Right_Arrows_Released.c Search_Pressed.c Search_Released.c ShutDown.c Signal1.c Signal2.c Signal3.c Signal4.c Signal5.c Signal6.c StartUpLogo.c Test_Pressed.c Test_Released.c TestGif.c Tool_Pressed.c Tool_Released.c Image.c
  group User/Res/Font
    ../User/Res/Font/: AraialNarrow16Tiny.c AraialNarrow18Tiny.c AraialNarrow20Tiny.c AraialNarrow22Tiny.c KaiTi33BoldTiny.c SongTi24.c SongTiBold19.c SongTiBold24.c SongTiBold33.c SpaceKey.c SwitchKey.c Tahoma16.c Tahoma23.c Tahoma58.c TahomaBold18.c TahomaBold19.c TahomaBold23.c TahomaBold33.c TimesNewRoman19.c TimesNewRoman21.c TimesNewRoman55.c TimesNewRoman73.c Triangle.c Uparrow.c WeiruanYaHei18Tiny.c SongTi18_Warning.c Tabs.c
  group User/UserWindow
    ../User/UserWindow/: UserMainWindow.c Window_Common_Process.c SettingMainWindow.c AutoShutdownTimeWindow.c TestMainWindow.c ShowReportWindow.c InputNumberWindow.c Setting_BackLight_Timeout.c ShowDialogWindow.c Setting_BackLight.c Setting_System_Info_Window.c ToolSetTimeWindow.c TouchCaliWindow.c AdminWindow.c TimeZoneSetting.c ToolSetBlow.c ToolSetALCUnitsWindow.c DebugWindow.c CalibrationWindow.c InputPlateNumWindow.c PrintCopys.c PrintRecordWindow.c DisplayRecordWindow.c SampleModeWindow.c UserManageWindow.c SelectEnrollUser.c HeartRate.c InputKeyboard.c InputWindow.c
  group Periph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group GUI/AntiAlias
    ../GUI/AntiAlias/: GUIAAArc.c GUIAAChar.c GUIAAChar2.c GUIAAChar4.c GUIAACircle.c GUIAALib.c GUIAALine.c GUIAAPoly.c GUIAAPolyOut.c
  group GUI/ConvertColor
    ../GUI/ConvertColor/: LCDP111.c LCDP222.c LCDP233.c LCDP323.c LCDP332.c LCDP444_12.c LCDP444_12_1.c LCDP444_16.c LCDP555.c LCDP556.c LCDP565.c LCDP655.c LCDP8666.c LCDP8666_1.c LCDPM233.c LCDPM323.c LCDPM332.c LCDPM444_12.c LCDPM444_16.c LCDPM555.c LCDPM556.c LCDPM565.c LCDPM655.c LCDP666.c LCDP888.c LCDPM666.c LCDPM888.c
  group GUI/ConvertMono
    ../GUI/ConvertMono/: LCDP0.c LCDP2.c LCDP4.c
  group GUI/Core
    ../GUI/Core/: GUI__AddSpaceHex.c GUI__CalcTextRect.c GUI__DivideRound.c GUI__DivideRound32.c GUI__GetFontSizeY.c GUI__GetNumChars.c GUI__HandleEOLine.c GUI__IntersectRect.c GUI__IntersectRects.c GUI__memset.c GUI__memset16.c GUI__Read.c GUI__ReduceRect.c GUI__SetText.c GUI__strcmp.c GUI__strlen.c GUI__Wrap.c GUI_AddBin.c GUI_AddDec.c GUI_AddDecMin.c GUI_AddDecShift.c GUI_AddHex.c GUI_AddKeyMsgHook.c GUI_ALLOC_AllocInit.c GUI_ALLOC_AllocZero.c GUI_BMP.c GUI_BMP_Serialize.c GUI_CalcColorDist.c GUI_ClearRectEx.c GUI_Color2VisColor.c GUI_CursorArrowL.c GUI_CursorArrowLI.c GUI_CursorArrowLPx.c GUI_CursorArrowM.c GUI_CursorArrowMI.c GUI_CursorArrowMPx.c GUI_CursorArrowS.c GUI_CursorArrowSI.c GUI_CursorArrowSPx.c GUI_CursorCrossL.c GUI_CursorCrossLI.c GUI_CursorCrossLPx.c GUI_CursorCrossM.c GUI_CursorCrossMI.c GUI_CursorCrossMPx.c GUI_CursorCrossS.c GUI_CursorCrossSI.c GUI_CursorCrossSPx.c GUI_CursorHeaderM.c GUI_CursorHeaderMI.c GUI_CursorHeaderMPx.c GUI_CursorPal.c GUI_CursorPalI.c GUI_DispBin.c GUI_DispCEOL.c GUI_DispChar.c GUI_DispChars.c GUI_DispHex.c GUI_DispString.c GUI_DispStringAt.c GUI_DispStringAtCEOL.c GUI_DispStringHCenter.c GUI_DispStringInRect.c GUI_DispStringInRectEx.c GUI_DispStringInRectWrap.c GUI_DispStringLen.c GUI_DrawBitmap.c GUI_DrawBitmapEx.c GUI_DrawBitmapExp.c GUI_DrawBitmapMag.c GUI_DrawFocusRect.c GUI_DrawGraph.c GUI_DrawHLine.c GUI_DrawPie.c GUI_DrawPixel.c GUI_DrawPolyline.c GUI_DrawRectEx.c GUI_DrawVLine.c GUI_ErrorOut.c GUI_Exec.c GUI_FillPolygon.c GUI_FillRect.c GUI_FillRectEx.c GUI_GetBitmapPixelColor.c GUI_GetBitmapPixelIndex.c GUI_GetClientRect.c GUI_GetColor.c GUI_GetDispPos.c GUI_GetFont.c GUI_GetFontInfo.c GUI_GetFontSizeY.c GUI_GetLineStyle.c GUI_GetStringDistX.c GUI_GetTextAlign.c GUI_GetTextExtend.c GUI_GetTextMode.c GUI_GetVersionString.c GUI_GetYSizeOfFont.c GUI_GIF.c GUI_Goto.c GUI_InitLUT.c GUI_InvertRect.c GUI_IsInFont.c GUI_Log.c GUI_MergeRect.c GUI_MOUSE.c GUI_MOUSE_DriverPS2.c GUI_MoveRect.c GUI_OnKey.c GUI_Pen.c GUI_PID.c GUI_RectsIntersect.c GUI_SaveContext.c GUI_SelectLayer.c GUI_SelectLCD.c GUI_SetClipRect.c GUI_SetColor.c GUI_SetColorIndex.c GUI_SetDecChar.c GUI_SetDefault.c GUI_SetDrawMode.c GUI_SetFont.c GUI_SetLBorder.c GUI_SetLineStyle.c GUI_SetLUTColor.c GUI_SetLUTColorEx.c GUI_SetLUTEntry.c GUI_SetOrg.c GUI_SetPixelIndex.c GUI_SetTextAlign.c GUI_SetTextMode.c GUI_SetTextStyle.c GUI_SIF.c GUI_SIF_Prop.c GUI_TOUCH.c GUI_TOUCH_DriverAnalog.c GUI_TOUCH_StoreState.c GUI_TOUCH_StoreUnstable.c GUI_UC.c GUI_UC_DispString.c GUI_UC_EncodeNone.c GUI_UC_EncodeUTF8.c GUI_WaitEvent.c GUI_WaitKey.c GUI_Warn.c GUI2DLib.c GUIAlloc.c GUIArc.c GUIChar.c GUICharLine.c GUICharM.c GUICharP.c GUICirc.c GUIColor2Index.c GUICore.c GUICurs.c GUIEncJS.c GUIIndex2Color.c GUIPolyE.c GUIPolyM.c GUIPolyR.c GUIRealloc.c GUIStream.c GUITask.c GUITime.c GUITimer.c GUIUC0.c GUIVal.c GUIValf.c LCD.c LCD_API.c LCD_DrawVLine.c LCD_GetColorIndex.c LCD_GetEx.c LCD_GetNumDisplays.c LCD_GetPixelColor.c LCD_Index2ColorEx.c LCD_L0_Generic.c LCD_Mirror.c LCD_MixColors256.c LCD_Rotate180.c LCD_RotateCCW.c LCD_RotateCW.c LCD_SelectLCD.c LCD_SetAPI.c LCD_SetClipRectEx.c LCD_UpdateColorIndices.c LCDAA.c LCDColor.c LCDGetP.c LCDInfo.c LCDInfo0.c LCDInfo1.c LCDL0Delta.c LCDL0Mag.c LCDP1.c LCDP565_Index2Color.c LCDPM565_Index2Color.c LCDRLE4.c LCDRLE8.c GUI__Arabic.c GUI__DrawBitmap16bpp.c GUI__GetCursorPos.c GUI_DrawBitmap_555.c GUI_DrawBitmap_565.c GUI_DrawBitmap_888.c GUI_DrawGraphEx.c GUI_DrawLine.c GUI_DrawPoint.c GUI_DrawPolygon.c GUI_GetDrawMode.c GUI_GetOrg.c GUI_ScreenSize.c GUI_UC_ConvertUC2UTF8.c GUI_UC_ConvertUTF82UC.c LCD_ReadRect.c LCDP888_Index2Color.c LCDPM888_Index2Color.c LCDRLE16.c
  group GUI/Font
    ../GUI/Font/: F4x6.c F6x8.c F08_1.c F08_ASCII.c F8x8.c F8x10_ASCII.c F8x12_ASCII.c F8x13_1.c F8x13_ASCII.c F8x15B_1.c F8x15B_ASCII.c F8x16.c F10_1.c F10_ASCII.c F10S_1.c F10S_ASCII.c F13_1.c F13_ASCII.c F13B_1.c F13B_ASCII.c F13H_1.c F13H_ASCII.c F13HB_1.c F13HB_ASCII.c F16_1.c F16_1HK.c F16_ASCII.c F16_HK.c F16B_1.c F16B_ASCII.c F24_1.c F24_ASCII.c F24B_1.c F24B_ASCII.c F32_1.c F32_ASCII.c F32B_1.c F32B_ASCII.c FComic18B_1.c FComic18B_ASCII.c FComic24B_1.c FComic24B_ASCII.c FD24x32.c FD32.c FD36x48.c FD48.c FD48x64.c FD60x80.c FD64.c FD80.c
  group GUI/Jepg
    ../GUI/JPEG/: GUI_JPEG.c jcomapi.c jdapimin.c jdapistd.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdphuff.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jidctred.c jmemmgr.c jquant1.c jquant2.c jutils.c
  group GUI/LcdDriver
    ../GUI/LCDDriver/: LCDDriver.c CustomDisplayDriver.c
  group GUI/MemDev
    ../GUI/MemDev/: GUIDEV.c GUIDEV_1.c GUIDEV_8.c GUIDEV_16.c GUIDEV_AA.c GUIDEV_Auto.c GUIDEV_Banding.c GUIDEV_Clear.c GUIDEV_CmpWithLCD.c GUIDEV_CopyFromLCD.c GUIDEV_CreateFixed.c GUIDEV_GetDataPtr.c GUIDEV_GetXSize.c GUIDEV_GetYSize.c GUIDEV_Measure.c GUIDEV_ReduceYSize.c GUIDEV_SetOrg.c GUIDEV_Usage.c GUIDEV_UsageBM.c GUIDEV_Write.c GUIDEV_WriteAlpha.c GUIDEV_WriteEx.c GUIDEV_XY2PTR.c
  group GUI/MultiLayer
    ../GUI/MultiLayer/: LCD_1.c LCD_2.c LCD_3.c LCD_4.c
  group GUI/Widget
    ../GUI/Widget/: BUTTON.c BUTTON__SetBitmapObj.c BUTTON_Bitmap.c BUTTON_BMP.c BUTTON_Create.c BUTTON_CreateIndirect.c BUTTON_Default.c BUTTON_Get.c BUTTON_IsPressed.c BUTTON_SelfDraw.c BUTTON_SetTextAlign.c BUTTON_StreamedBitmap.c CHECKBOX.c CHECKBOX_Create.c CHECKBOX_CreateIndirect.c CHECKBOX_Default.c CHECKBOX_GetState.c CHECKBOX_Image.c CHECKBOX_IsChecked.c CHECKBOX_SetBkColor.c CHECKBOX_SetDefaultImage.c CHECKBOX_SetFont.c CHECKBOX_SetImage.c CHECKBOX_SetNumStates.c CHECKBOX_SetSpacing.c CHECKBOX_SetState.c CHECKBOX_SetText.c CHECKBOX_SetTextAlign.c CHECKBOX_SetTextColor.c DIALOG.c DROPDOWN.c DROPDOWN_Create.c DROPDOWN_CreateIndirect.c DROPDOWN_DeleteItem.c DROPDOWN_InsertString.c DROPDOWN_ItemSpacing.c DROPDOWN_SetAutoScroll.c DROPDOWN_SetTextAlign.c DROPDOWN_SetTextHeight.c EDIT.c EDIT_Create.c EDIT_CreateIndirect.c EDIT_Default.c EDIT_GetCursorPos.c EDIT_GetNumChars.c EDIT_SetCursorAtChar.c EDIT_SetInsertMode.c EDIT_SetpfAddKeyEx.c EDIT_SetpfUpdateBuffer.c EDIT_SetSel.c EDITBin.c EDITDec.c EDITFloat.c EDITHex.c FRAMEWIN.c FRAMEWIN__UpdateButtons.c FRAMEWIN_AddMenu.c FRAMEWIN_Button.c FRAMEWIN_ButtonClose.c FRAMEWIN_ButtonMax.c FRAMEWIN_ButtonMin.c FRAMEWIN_Create.c FRAMEWIN_CreateIndirect.c FRAMEWIN_Default.c FRAMEWIN_Get.c FRAMEWIN_IsMinMax.c FRAMEWIN_MinMaxRest.c FRAMEWIN_SetBorderSize.c FRAMEWIN_SetColors.c FRAMEWIN_SetFont.c FRAMEWIN_SetResizeable.c FRAMEWIN_SetTitleHeight.c FRAMEWIN_SetTitleVis.c GUI_ARRAY.c GUI_ARRAY_DeleteItem.c GUI_ARRAY_InsertItem.c GUI_ARRAY_ResizeItem.c GUI_DRAW.c GUI_DRAW_BITMAP.c GUI_DRAW_BMP.c GUI_DRAW_Self.c GUI_DRAW_STREAMED.c GUI_EditBin.c GUI_EditDec.c GUI_EditFloat.c GUI_EditHex.c GUI_EditString.c GUI_HOOK.c HEADER.c HEADER__SetDrawObj.c HEADER_Bitmap.c HEADER_BMP.c HEADER_Create.c HEADER_CreateIndirect.c HEADER_StreamedBitmap.c LISTBOX.c LISTBOX_Create.c LISTBOX_CreateIndirect.c LISTBOX_Default.c LISTBOX_DeleteItem.c LISTBOX_Font.c LISTBOX_GetItemText.c LISTBOX_GetNumItems.c LISTBOX_InsertString.c LISTBOX_ItemDisabled.c LISTBOX_ItemSpacing.c LISTBOX_MultiSel.c LISTBOX_ScrollStep.c LISTBOX_SetAutoScroll.c LISTBOX_SetBkColor.c LISTBOX_SetOwner.c LISTBOX_SetOwnerDraw.c LISTBOX_SetScrollbarWidth.c LISTBOX_SetString.c LISTBOX_SetTextAlign.c LISTBOX_SetTextColor.c LISTVIEW.c LISTVIEW_Create.c LISTVIEW_CreateIndirect.c LISTVIEW_Default.c LISTVIEW_DeleteColumn.c LISTVIEW_DeleteRow.c LISTVIEW_GetBkColor.c LISTVIEW_GetFont.c LISTVIEW_GetHeader.c LISTVIEW_GetNumColumns.c LISTVIEW_GetNumRows.c LISTVIEW_GetSel.c LISTVIEW_GetTextColor.c LISTVIEW_SetBkColor.c LISTVIEW_SetColumnWidth.c LISTVIEW_SetFont.c LISTVIEW_SetGridVis.c LISTVIEW_SetItemColor.c LISTVIEW_SetItemText.c LISTVIEW_SetLBorder.c LISTVIEW_SetRBorder.c LISTVIEW_SetRowHeight.c LISTVIEW_SetSel.c LISTVIEW_SetTextAlign.c LISTVIEW_SetTextColor.c MENU.c MENU__FindItem.c MENU_Attach.c MENU_CreateIndirect.c MENU_Default.c MENU_DeleteItem.c MENU_DisableItem.c MENU_EnableItem.c MENU_GetItem.c MENU_GetItemText.c MENU_GetNumItems.c MENU_InsertItem.c MENU_Popup.c MENU_SetBkColor.c MENU_SetBorderSize.c MENU_SetFont.c MENU_SetItem.c MENU_SetTextColor.c MESSAGEBOX.c MULTIEDIT.c MULTIEDIT_Create.c MULTIEDIT_CreateIndirect.c MULTIPAGE.c MULTIPAGE_Create.c MULTIPAGE_CreateIndirect.c MULTIPAGE_Default.c PROGBAR.c PROGBAR_Create.c PROGBAR_CreateIndirect.c RADIO.c RADIO_Create.c RADIO_CreateIndirect.c RADIO_Default.c RADIO_Image.c RADIO_SetBkColor.c RADIO_SetDefaultImage.c RADIO_SetFont.c RADIO_SetGroupId.c RADIO_SetImage.c RADIO_SetText.c RADIO_SetTextColor.c SCROLLBAR.c SCROLLBAR_Create.c SCROLLBAR_CreateIndirect.c SCROLLBAR_Defaults.c SCROLLBAR_GetValue.c SCROLLBAR_SetWidth.c SLIDER.c SLIDER_Create.c SLIDER_CreateIndirect.c TEXT.c TEXT_Create.c TEXT_CreateIndirect.c TEXT_SetBkColor.c TEXT_SetFont.c TEXT_SetText.c TEXT_SetTextAlign.c TEXT_SetTextColor.c TEXT_SetWrapMode.c WIDGET.c WIDGET_Effect_3D.c WIDGET_Effect_3D1L.c WIDGET_Effect_3D2L.c WIDGET_Effect_None.c WIDGET_Effect_Simple.c WIDGET_FillStringInRect.c WIDGET_SetEffect.c WIDGET_SetWidth.c WINDOW.c WINDOW_Default.c BUTTON_GetBitmap.c BUTTON_SetFocusColor.c CHECKBOX_GetText.c CHECKBOX_SetBoxBkColor.c CHECKBOX_SetFocusColor.c DROPDOWN_AddString.c DROPDOWN_Default.c DROPDOWN_GetNumItems.c DROPDOWN_SetBkColor.c DROPDOWN_SetColor.c DROPDOWN_SetFont.c DROPDOWN_SetScrollbarColor.c DROPDOWN_SetScrollbarWidth.c DROPDOWN_SetTextColor.c EDIT_GetCursorPixelPos.c EDIT_SetFocussable.c EDIT_SetTextMode.c EDITUlong.c GRAPH.c GRAPH_CreateIndirect.c GRAPH_DATA_XY.c GRAPH_DATA_YT.c GRAPH_SCALE.c HEADER_GetSel.c HEADER_SetDragLimit.c LISTBOX_GetTextAlign.c LISTBOX_SetScrollbarColor.c LISTVIEW_DeleteAllRows.c LISTVIEW_DisableRow.c LISTVIEW_GetItemText.c LISTVIEW_InsertRow.c LISTVIEW_SetAutoScroll.c LISTVIEW_SetSort.c LISTVIEW_UserData.c PROGBAR_SetBarColor.c PROGBAR_SetFont.c PROGBAR_SetMinMax.c PROGBAR_SetText.c PROGBAR_SetTextAlign.c PROGBAR_SetTextColor.c PROGBAR_SetTextPos.c RADIO_GetText.c RADIO_SetFocusColor.c SCROLLBAR_SetColor.c SLIDER_Default.c SLIDER_SetFocusColor.c TEXT_Default.c
  group GUI/WM
    ../GUI/WM/: WM.c WM__ForEachDesc.c WM__GetFirstSibling.c WM__GetFocussedChild.c WM__GetLastSibling.c WM__GetOrg_AA.c WM__GetPrevSibling.c WM__IsAncestor.c WM__IsChild.c WM__IsEnabled.c WM__NotifyVisChanged.c WM__Screen2Client.c WM__SendMessage.c WM__SendMessageIfEnabled.c WM__SendMessageNoPara.c WM__UpdateChildPositions.c WM_AttachWindow.c WM_BringToBottom.c WM_BringToTop.c WM_Broadcast.c WM_CheckScrollPos.c WM_CriticalHandle.c WM_DIAG.c WM_EnableWindow.c WM_ForEachDesc.c WM_GetBkColor.c WM_GetClientRect.c WM_GetClientWindow.c WM_GetDesktopWindow.c WM_GetDesktopWindowEx.c WM_GetDiagInfo.c WM_GetDialogItem.c WM_GetFirstChild.c WM_GetFlags.c WM_GetFocussedWindow.c WM_GetId.c WM_GetInsideRect.c WM_GetInsideRectExScrollbar.c WM_GetInvalidRect.c WM_GetNextSibling.c WM_GetOrg.c WM_GetParent.c WM_GetPrevSibling.c WM_GetScrollbar.c WM_GetScrollPartner.c WM_GetScrollState.c WM_GetWindowRect.c WM_GetWindowSize.c WM_HasCaptured.c WM_HasFocus.c WM_Hide.c WM_IsCompletelyVisible.c WM_IsEnabled.c WM_IsFocussable.c WM_IsVisible.c WM_IsWindow.c WM_MakeModal.c WM_Move.c WM_MoveChildTo.c WM_NotifyParent.c WM_OnKey.c WM_Paint.c WM_PID__GetPrevState.c WM_ResizeWindow.c WM_Screen2Win.c WM_SendMessageNoPara.c WM_SendToParent.c WM_SetAnchor.c WM_SetCallback.c WM_SetCapture.c WM_SetCaptureMove.c WM_SetCreateFlags.c WM_SetDesktopColor.c WM_SetFocus.c WM_SetFocusOnNextChild.c WM_SetFocusOnPrevChild.c WM_SetId.c WM_SetpfPollPID.c WM_SetScrollbar.c WM_SetScrollState.c WM_SetSize.c WM_SetTrans.c WM_SetTransState.c WM_SetUserClipRect.c WM_SetXSize.c WM_SetYSize.c WM_Show.c WM_StayOnTop.c WM_Timer.c WM_TimerExternal.c WM_UserData.c WM_Validate.c WM_ValidateWindow.c WMMemDev.c WMTouch.c WM_GetCallback.c WM_GetScrollPos.c WM_InvalidateArea.c WM_PaintWindowAndDescs.c WM_SetScrollPos.c WM_SetWindowPos.c WM_SIM.c WM_UpdateWindowAndDescs.c
  group GUI_X
    ../GUI_X/: GB2312Ex.c UnicodeEx.c GUI_X_Touch.c GUI_X.c
  group TJpgDecode
    ../User/Tjpgdecode/: tjpgd.c tjpgd_user.c
